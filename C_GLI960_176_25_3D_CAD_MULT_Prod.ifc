Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-05-17T13:44:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 17 13:44:24 2024 * Host: 105VN589 * Database: C:\Users\truole\AppData\Local\Temp\{23991037-1F27-4748-9445-61E3BFF6046F}\ifc * Database version: 5507 * Database creation date: Fri May 17 13:44:24 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 17 13:44:24 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 17 13:44:24 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\New folder\RFA 3D\GLI960_176_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GLI960_176_25, GLI960_176_25:GLI960_176_25:158939
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: GLI960/176/2.5
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.000212219 m3
Other - Category: Structural Connections; Family: GLI960_176_25: GLI960_176_25; Family and Type: GLI960_176_25: GLI960_176_25; Schedule Level: Level: Level 1; Type: GLI960_176_25: GLI960_176_25; Type Id: GLI960_176_25: GLI960_176_25; Family Name: GLI960_176_25
Phasing - Phase Created: New Construction
General - Density: 1.7; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLI960/176/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model: GLI960/176/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0146467085740187701958569546922077053277; Name: GLI960/176/2.5; ObjectType: GLI960/176/2.5; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: GLI960_176_25; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
